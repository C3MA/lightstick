# Repository C3MA/lightstick

File README.md:

# Lighstick
## Interfaces
* WS2812 - LED output
* UART (needed for programming and debugging)
* TCP-Port 2323 Telnet/Netcat
* UDP-Port 2342 RGB information

## UDP RGB Protocol
* Header
  * ID (one byte) - uniq identifier of one ledstick
  * Delay (one byte in ms)
  * timestamp in milliseconds only last two bytes
* RGB
  * LED1
    * red (one byte)
    * green (one byte)
    * blue (one byte)
  * LED2
    * red (one byte)
    * green (one byte)
    * blue (one byte)
  * LED ...

Header is at the moment 4 bytes

# Links
* https://www.ccc-mannheim.de/wiki/ESP8266/Lightstick

#TrackerStick
Tracker files player (xm,mod,s3m) that creates light patterns based on the used notes and instruments in the tracker file.

Examples using the EmuStick software:

 * https://www.youtube.com/watch?v=BA6pZhu4QjQ
 * https://www.youtube.com/watch?v=6QiemtzXNDI

## EAGLE design patterngenerator/ambi-light/powersupply/Ambi-Light.brd

Parts:
POWER-CON: PINHD-1X2; 1X02
PROG: PINHD-1X3; 1X03
U$1: ESP01
UART: PINHD-1X3; 1X03
VOLTAGECONVERTER: PINHD-1X3; 1X03
WS2812: PINHD-1X3; 1X03

Connections:
GND: POWER-CON.2, PROG.3, U$1.GND, UART.3, VOLTAGECONVERTER.1, WS2812.3
GPIO0: PROG.2, U$1.GPIO0
GPIO2: U$1.GPIO2, WS2812.2
RXD: U$1.RX (RXD), UART.1
TXD: U$1.TX (TXD), UART.2
VCC33: PROG.1, U$1.CH_PD, U$1.RST, U$1.VCC, VOLTAGECONVERTER.2
VCC50: POWER-CON.1, VOLTAGECONVERTER.3, WS2812.1

Board: 2 copper layers, 50.0 x 30.0 mm, 6 parts (0 on the bottom side), 7 nets.

## EAGLE design powersupply/lightstick.brd

Parts:
C1, C2: 1u; C0805
C3: 100u; PANASONIC_D
C4: 470u; PANASONIC_F
D1: MBRS340T3; SMC
JP1, JP2, JP3: PINHD-1X3; 1X03
JP4, JP5: PINHD-1X1; 1X01
L1: L-PWRIND12X12X7; L12X12X7
U1: MCP1703AT-3302E/CB; SOT95P300X145-3N
U$1: ESP8266
U$2: LM2576S5,0; TO-263
U$3, U$4: AKL383-02

Connections:
+3V3: C2.1, JP2.1, U1.2 (VOUT), U$1.CH_PD, U$1.GPIO16 (RST), U$1.VCC
+5V: C1.1, C4.+, JP1.1, L1.P$2, U1.3 (VIN), U$2.FEEDBACK
+12V: C3.+, U$2.VIN, U$3.PAD1 (PIN1), U$4.PAD1 (PIN1)
DATA: JP1.2, U$1.GPIO2 (DATA/GPIO2)
GND: C1.2, C2.2, C3.-, C4.-, D1.A, JP1.3, JP2.3, JP3.3, JP4.1, JP5.1, U1.1 (GND), U$1.GND, U$2.GND, U$2.GROUND, U$2.OFF, U$3.PAD2 (PIN2), U$4.PAD2 (PIN2)
unnamed: D1.C, L1.P$1, U$2.OUTPUT
PROGRAM: JP2.2, U$1.GPIO0
RX: JP3.1, U$1.URXD (RX)
TX: JP3.2, U$1.UTXD (TX)

Notes on the sheet:
power supply 2 connectors to allow daisy chain
to LED stripe
programming switch
for programming: connect GPIO0 to GND for normal operation: connect GPIO to +3V3
UART
Voltage regulator 5V -> 3V3
ESP 8266 controller
12V -> 5V voltage regulator
connection GND top side / bottom side

Board: 2 copper layers, 50.0 x 35.0 mm, 16 parts (6 on the bottom side), 9 nets.

## Commit log

2015-04-11 started empty project
2015-04-11 added connector for 12V power supply
2015-04-11 added connector for LED stripe
2015-04-11 added switch for programming mode
2015-04-11 added UART connector
2015-04-11 added voltage regulator for 3V3
2015-04-11 corrected comment regarding programming switch
2015-04-11 added ESP 8266 controller
2015-04-11 added voltage regulator for 5V and cleaned up schematic
2015-04-11 first draft of boad layout
2015-04-12 new layout + routing
2015-04-12 added value for C3
2015-04-12 changed routing of +5V power line; changed C3, C4 footprint
2015-04-12 removed TODOs (changes made in 6ee177d3be910101bcea379d1acf5b68e0139386)
2015-04-12 changed D1 to correct part
2015-04-12 changed D1 to MBRS340
2015-04-12 changed power connector
2015-04-12 changed isolation to greater value
2015-04-24 Progamming script included
2015-04-24 Added the required LUA firmware version
2015-04-24 First try
2015-04-24 test
2015-04-24 DemoLauflicht in Python
2015-04-24 UDP server is working
2015-04-24 Fixed command
2015-04-26 Changed Wifi
2015-04-26 Display the IP on the stripe
2015-04-26 Version number fixed
2015-04-26 Remote and serial flashing can be done both
2015-04-26 Paralell output is working
2015-04-26 Reduced light brightness
2015-04-26 Refactored with Stick count
2015-04-26 Generate also load
2015-04-26 Refactored update message into a seperate function
2015-04-26 Double refresh rate vs. dot updating
2015-04-26 Three times
2015-05-01 Image generated
2015-05-01 Simple test: print the time of the internal clock
2015-05-01 Some documentation added
2015-05-01 Sorted files
2015-05-01 Renamed
2015-05-01 New example
2015-05-01 Some modification done
2015-05-01 lightstick emulator
2015-05-01 instructions Signed-off-by: Kai Boernert <kai-boernert@visiongamestudios.de>
2015-05-01 Broke script
2015-05-01 Improved Readme
2015-05-01 Described header
2015-05-01 Fixed typo
2015-05-01 Moved emulator around
2015-05-01 More documentation
2015-05-01 Some more documentation
2015-05-01 Began with simulation and esp usage in paralell
2015-05-02 The 'old' load test
2015-05-02 Moved files around
2015-05-02 Added the flash command
2015-05-02 Some install instraction written down
2015-05-02 Made docu consistent
2015-05-09 Ignore the header in the firmware
2015-05-09 Example can be controlled via arguments where to send to
2015-05-09 Fixed cleaning when moving up
2015-05-09 Header changed to 3, as we want to ignore byte0 - byte3
2015-05-09 Header is removed
2015-05-09 Switch init
2015-05-30 changes for stick
2015-06-26 ibxm changes lights
2015-07-03 changed minimum route width to .6mm
2015-07-03 changed some wires to improve GND plane connectivity
2015-07-03 rerouting to accomodate easier soldering. connected GND top and bottom planes
2015-07-03 updated version number
2015-07-04 Cleaned up folder names
2015-07-04 Start porting perlin noise (tobima) from Fullcircle
2015-07-05 some output of to the commandline added
2015-07-05 included GC again, helped
2015-07-09 GUI is showing something
2015-07-09 Some documentation
2015-07-09 Updated default values, fitting better for sticks
2015-07-09 Prepared UDP sending
2015-07-14 stick scanning
2015-07-17 Board modified for new inductor, changed side of capacitor
2015-07-17 Perlin noise generation shows something in the emulator
2015-07-17 PCB designed improved, minor changes
2015-07-18 Added new script to read the MAC address; better documentation; Powersupply board improvements
2015-07-18 Added orange leds to fill the foot
2015-07-18 less bright orange
2015-07-20 Some formating
2015-07-20 Removed unused parameter
2015-07-29 modulo over the used tracks for all sticks
2015-08-04 Added new complete flash script
2015-08-04 Removed file from wrong project
2015-08-07 retry untill sticks found
2015-08-12 Pattern Generator generating changed
2015-08-12 Python changes
2015-08-12 Files found on the raspberry
2015-08-13 Some changes found on the device
2015-08-13 Font testing stuff
2015-08-14 New project added to display text on the sticks
2015-08-14 Added possebility to test the text logic against the simulator
2015-08-14 Removed old code
2015-08-14 We found the same column
2015-08-14 Shrinked text
2015-08-14 It is perfectly narrow
2015-08-14 The color and the amount of sticks can be set
2015-08-14 Prepared scrolling
2015-08-14 Text is scrolling
2015-08-14 Text and background colors can be set
2015-08-14 Added parameter to definde the amount of pixel between the top of the sticks and the text
2015-08-16 Backuped scripts from Raspberry pi
2015-08-16 Qt-Project to send the an video file to the sticks
2015-09-12 inverted every 2nd row, smaller improvements
2016-01-09 Deleted Swap file and checked in the newest working version from the raspberry
2016-01-09 Extended Framework: - Add class "MarqueeText" which animates a given text and includes all functionality from run.sh - Add properties to the class "Wall" - move the argparser part in a separate file
2016-01-09 - Rename framework.py to Framework.py (due to naming convention) - replace run.sh by run.py
2016-01-18 uncommited stuff
2016-04-09 2D Projekt
    Umbau der Lightsticks in leichter transportierbare Installation
2016-04-09 ambi light
    kleines Ambiente Licht
2016-07-27 added powersupply eagle design
    added powersupply eagle design
